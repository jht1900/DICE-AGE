/*
*/

#include "qDef.h"
#include "Stream.h"

#include "TxtObj.h"
#include "Obj.h"

/* -------------------------------------------------------------------- */

#define TRACE(a,b) /* printf b */

extern TxtObj	*me;

extern Env		*ev;

/* ------------------------ DoFuncDoc ---------------------------------- */

TxtObj	*funcWindow;

DoFuncDoc()
	{
	TxtObj		*ome;
	int			InsertFuncName();
	static Rect	rt = { 40, 350, 200, 500 };
	
	ome = me;
	TxtNew(&rt, "\pFunc Doc");
	funcWindow = me;
	
	CMapatoms( InsertFuncName );
	
	me = ome;
	}
	
InsertFuncName(sy)
	qSymbol	*sy;
	{
	qIfunc	*fp;
	
	TEInsert( sy->name + 1, (long) sy->name[0], me->TEH );
	
	fp = (qIfunc *) sy->func;
	if (Funcp(fp) && fp->doc)
		{
		TEInsert( " - ", 3L, me->TEH );
		TEInsert( fp->doc, (long) strlen(fp->doc), me->TEH);
		}

	TEInsert( "\r", 1L, me->TEH );
	}

CMapatoms(fp)
	int	(*fp)();
	{
	register qList	*lp;
	register long	i;
	
	for (i = 0; i < ev->tabSize; i++)
		{
		for (lp = ev->symTab[i]; Listp(lp); lp = Cdr(lp) )
			{
			(*fp)( Car(lp) );
			}
#if 0
		if (Listp(ev->symTab[i]))
			{
			printf("i=%ld\n", i);
			TEInsert( "----\r", 5L, me->TEH );
			}
#endif
		}
	}
	