/*
*/

#include "cGlob.h"

/* --------------------------------------------------------------------- */

cGetGlobalDef()
	{
	TypeDeclArg		td;
	Ent				*tok;
	
	TRACE(1,("cGetGlobalDef\n"));
	
	/* Get base type and storage class */
	td.allowNullId = 0;
	td.storage = externStore;
	cGetStorageBaseType(&td);
	
	/* Allow only static or extern storage class at global level */
	if (td.storage != externStore && td.storage != staticStore)
		cParseError("invalid storage class");
		
	/* Check for end of statement, this was a type definition only */
	tok = cGetToken();
	if (TermType(tok) == semicolonTerm)
		return;
	cUngetToken(tok);
	
	cGetDecl(&td);
	
	if (td.storage == typedefStore)
		{
		cGetTypedefList(&td);
		return;
		}
		
	tok = cGetToken();
	switch (TermType(tok) )
		{
		case lparenTerm:
			cGetFuncDef(&td);
			break;
		
		case commaTerm:
		case semicolonTerm:
		case equalTerm:
			cUngetToken(tok);
			cGetVarDefList(&td);
			break;
			
		case lcurlyTerm:
			cUngetToken(tok);
			cGetFuncDefNoArgs();
			break;
		
		default:
			cSyntaxError();
			break;
		}
	}

/* --------------------------------------------------------------------- */

cGetTypedefList(td)
	TypeDeclArg		*td;
	{
	TRACE(1,("cGetTypedefList\n"));
	}
	
/* --------------------------------------------------------------------- */

cGetFuncDef(td)
	TypeDeclArg		*td;
	{
	/* lparen allready seen */
	TRACE(1,("cGetFuncDef\n"));
	}

/* --------------------------------------------------------------------- */

cGetFuncDefNoArgs()
	{
	/* lcurly up coming */
	TRACE(1,("cGetFuncDefNoArgs"));
	}
	
/* --------------------------------------------------------------------- */
