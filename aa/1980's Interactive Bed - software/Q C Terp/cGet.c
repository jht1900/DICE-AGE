/*
*/

#include <FileMgr.h>

#include "cScan_.h"

static int fileRef;
static int unch = -1;

/* ------------------  ----------------------------------------- */

/* ------------------ cGetChar ----------------------------------------- */

int	cGetChar()
	{
	unsigned char	buf[1];
	long	n;
	int		er;
	int		ch;
	
	if (unch >= 0)
		{
		ch = unch;
		unch = -1;
		return (ch);
		}
	
	n = 1;
	er = FSRead(fileRef, &n, &buf);
	if (er == eofErr)
		return (EndOfFile);
	if (er != noErr)
		{
		printf("read er=%d\n", er);
		}
		
	return (buf[0]);
	}

/* ------------------ cGetCharQuoted ----------------------------------------- */
	
int cGetCharQuoted()
	{
	return (cGetChar());
	}

/* ------------------ cUnGetChar ----------------------------------------- */

int cUnGetChar(ch)
	int		ch;
	{
	unch = ch;
	}

/* -------------------- cCloseFile ---------------------------------------- */

cCloseFile()
	{
	FSClose(fileRef);
	}
	
/* -------------------- cOpenFile ---------------------------------------- */

cOpenFile(fn)
	char	*fn;
	{
	int	er;
	
	er = FSOpen(fn, 0, &fileRef);
	if (er) printf("cOpenFile: er=%d\n", er);
	}
	
/* ------------------------------------------------------------------------- */
