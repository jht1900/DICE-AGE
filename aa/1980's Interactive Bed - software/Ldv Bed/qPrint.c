/*
*/

#include "qDef.h"
#include "Stream.h"

extern char	qtrace;
#define TRACE(a,b) if (qtrace>=a) printf b

PrintStream(ev, st, it)
	Env		*ev;
	Stream	*st;
	qItem	it;
	{
	Byte	buf[MaxStringLen+2];
	
	if (Nullp(it))
		{
		(*st->writef)(st, "()", 2);
		}
	else if (Symbolp(it))
		{
		(*st->writef)(st, ((qSymbol *)it)->name + 1, 
							((qSymbol *)it)->name[0]);
		}
	else if (Listp(it))
		{
		register qList *p;
		
		(*st->writef)(st, "(", 1);
		for (p = (qList *)it; Listp(p); p = Cdr(p))
			{
			PrintStream(ev, st, Car(p));
			if (Listp(Cdr(p)))
				(*st->writef)(st, " ", 1);
			}
		(*st->writef)(st, ")", 1);
		}
	else if (Nump(it))
		{
		sprintf(buf, "%ld", Cnum(it));
		(*st->writef)(st, buf, strlen(buf));
		}
	else if (Type(it) == qIstructType)
		{
		sprintf(buf, "<%.4s-%#lx>", it, it);
		(*st->writef)(st, buf, strlen(buf));
		}
	else if (Type(it) == qIfuncType)
		{
		sprintf(buf, "<%s-%#lx>", ((qIfunc *)it)->name, it);
		(*st->writef)(st, buf, strlen(buf));
		}
	else {
		sprintf(buf, "<%#lx>", it);
		(*st->writef)(st, buf, strlen(buf));
		}
	}