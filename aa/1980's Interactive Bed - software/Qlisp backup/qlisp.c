/* ldv1.c

It's not black, It's not white
it's nothing that you can see
*/

#include <Quickdraw.h>
#include <ResourceMgr.h>
#include <pascal.h>
#include <stdio.h>

#include "qDef.h"

char 			qtrace = 0;
#define TRACE(a,b) if (qtrace>=a) printf b

Env				*ev;

#include <setjmp.h>

jmp_buf			topleveljb;
int				fdload;

main ()
	{
#if 0
	Stdio_MacInit(TRUE);	
	InitGraf(&thePort);
	InitFonts();
	/* FlushEvents(everyEvent, 0); */
	InitWindows();
	InitMenus();
	TEInit();
	InitDialogs(0L);
	MaxApplZone();
#endif
				/* tabSize, symsUnit, strsUnit, consUnit */
	ev = NewEnv(1009, 256, 1024, 1024);

	InitSyms(ev);	
	InitFuncs(ev);
	InitConsole(ev);

	printf("Yooh!\n");

	for (;;)
		{
		if (setjmp(topleveljb) == 0)
			{
			ReadEval(ev);
			}
		else {
			FreeEnv(ev);
			LoadEnv(ev, fdload);
			InitSyms(ev);
			InitFuncs(ev);
			InitConsole(ev);
			}
		}
	}
	
InitFuncs(ev)
	Env				*ev;
	{
	extern qIfunc	qPrimIfunc;
	extern qIfunc	qPrimMacIfunc;
	extern qIfunc	ldvFuncs[];

	InternIfuncs(ev, &qPrimIfunc);
	InternIfuncs(ev, &qPrimMacIfunc);	
	}
	
ReadEval(ev)
	Env				*ev;
	{
	register qItem	q, fp;
	int				n;
	qList			*lp;
	
	q = ReadConsole(ev, "> ");
	if (Symbolp(q))
		{
		fp = ((qSymbol *)q)->func;
		n = Nargs(fp);
		if (n >= 0)
			{
			for (lp = (qList *)NIL; n > 0; n--)
				{
				lp = Cons(ev, ReadConsole(ev, "Arg> "), lp);
				}
			lp = Nreverse(lp);
			lp = Cons(ev, q, lp);
			q = Eval(ev, lp);
			}
		else {
			q = ((qSymbol *)q)->val;
			}
		}
	else {
		q = Eval(ev, q);
		}
		
	PrintConsole(ev, q);
	}
	
OhShit(ex, a, b, c, d, e, f, g)
	int ex;
	long a, b, c, d, e, f, g;
	{
	printf(a, b, c, d, e, f, g);
	if (ex) exit(0);
	}
	
/* ---------------------------------------------------------------- */
